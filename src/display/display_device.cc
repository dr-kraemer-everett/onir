#include "display_device.h"

#include "Arduino.h"
#include "Wire.h"

DisplayDevice::DisplayDevice(const Hardware& hardware) : hardware(hardware) {
  for (int i = 0; i < 7; i++) {
    segments[i] = (Function)(i + (int)Fn::dd_a);
  }
  for (int i = 0; i < 4; i++) {
    positions[i] = (Function)(i + (int)Fn::dd_1);
  }
  set_segment_masks();
  set_char_masks();
  for (int i = (int)Function::dd_a; i <= (int)Function::dd_4; i++) {
    pinMode(dispatch(hardware, (Function)i), OUTPUT);
  }
  message.clear();
  blank();
}

void DisplayDevice::blank() {
  for (Function segment : segments) {
    pin_low(segment);
  }
  set_point_pin(LOW);
  for (Function position : positions) {
    pin_high(position);
  }
}

int DisplayDevice::position_to_show() {
  return (millis() % ms_per_cycle) / ms_per_digit;
}

void DisplayDevice::set_fn_pin(Function fn, bool val) {
  digitalWrite(dispatch(hardware, fn), val);
}

void DisplayDevice::pin_high(Function fn) {
  set_fn_pin(fn, HIGH);
}

void DisplayDevice::pin_low(Function fn) {
  set_fn_pin(fn, LOW);
}

void DisplayDevice::set_point_pin(bool val) {
  set_fn_pin(Fn::dd_p, val);
}

void DisplayDevice::refresh() {

  int prior_position = position;
  if (prior_position != (position = position_to_show())) {  // redraw display
    blank();
    for (Function segment : segments) {
      if (segment_masks[(int)segment] & char_masks[(int)message.chars[position]]) {
        pin_high(segment);
      }
    }
    if (message.point == position) {
      set_point_pin(HIGH);
    }
    pin_low(positions[position]);
  }
}
